# Keil uVision project CMSIS_DV_API.uvprojx, settings and files
target Debug (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS_DV_API
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: main.c
  group Documentation
    ./: Abstract.txt
target Create Report (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: CMSIS_DV_API
  c flags: Optim=1 uC99=1
  c define: HSE_VALUE=25000000, PRINT_XML_REPORT=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS Driver Validation:Ethernet 1.0.0, CMSIS Driver Validation:Framework 1.0.0, CMSIS Driver Validation:I2C 1.0.0, CMSIS Driver Validation:MCI 1.0.0, CMSIS Driver Validation:SPI 1.0.0, CMSIS Driver Validation:USART 1.0.0, CMSIS Driver Validation:USB Device 1.0.0, CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:Ethernet MAC 2.8, CMSIS Driver:Ethernet PHY:ST802RT1 6.2.0, CMSIS Driver:I2C 2.8, CMSIS Driver:MCI 2.6, CMSIS Driver:SPI 2.8, CMSIS Driver:USART 2.8, CMSIS Driver:USB Device:Full-speed 2.18, Device:STM32Cube Framework:Classic 1.2.1, Device:STM32Cube HAL:ADC 1.2.1, Device:STM32Cube HAL:Common 1.2.1, Device:STM32Cube HAL:Cortex 1.2.1, Device:STM32Cube HAL:DMA 1.2.1, Device:STM32Cube HAL:GPIO 1.2.1, Device:STM32Cube HAL:I2C 1.2.1, Device:STM32Cube HAL:RCC 1.2.1, Device:STM32Cube HAL:SPI 1.2.1, Device:STM32Cube HAL:USART 1.2.1, Device:Startup 2.2.1
