# Keil uVision project SockServer.uvprojx, settings and files
target IMXRT1050-EVKB (6160000::V6.16::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.14.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL, CODEC_WM8960_ENABLE, SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1
  c include: .;..\..\Include
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20280000 size 0x40000
  memory RVCT7: RAM 0x20200000 size 0x80000
  memory RVCT8: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1052DVL6B\MIMXRT1052xxxxx.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group App
    ./: app_main.c
  group Board
    ./: main.c main.h
  group Board IO
    ./Board_IO/: retarget_stdio.c
  group MCUXpresso
    ./: IMXRT1050-EVKB.mex
  group Documentation
    ./: Abstract.txt
  group SockServer
    ../../Source/: SockServer.c Telnet_Server_UIF.c
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.5.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.16.0, Network:Interface:ETH 7.16.0, Network:Service:Telnet Server 7.16.0, Network:Socket:BSD 7.16.0, Network:Socket:TCP 7.16.0, Network:Socket:UDP 7.16.0, CMSIS Driver:Ethernet MAC 1.2.0, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:MCI 1.3.0, CMSIS Driver:VIO:Board 1.0.1, Board Support:SDK Drivers:evkbimxrt1050 2.0.1, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:USART:lpuart_cmsis 2.2.0, Device:CMSIS:MIMXRT1052_header 1.0.0, Device:CMSIS:MIMXRT1052_system 1.0.0, Device:SDK Drivers:cache 2.0.4, Device:SDK Drivers:clock 2.4.0, Device:SDK Drivers:codec 2.3.0, Device:SDK Drivers:codec_i2c 2.1.0, Device:SDK Drivers:common 2.3.1, Device:SDK Drivers:dmamux 2.0.5, Device:SDK Drivers:edma 2.4.3, Device:SDK Drivers:enet 2.5.3, Device:SDK Drivers:fxos8700cq 1.0.0, Device:SDK Drivers:gpio 2.0.5, Device:SDK Drivers:i2c 2.3.1, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpi2c_adapter 1.0.0, Device:SDK Drivers:lpuart 2.5.2, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:lpuart_edma 2.5.2, Device:SDK Drivers:nic301 2.0.0, Device:SDK Drivers:sai 2.3.4, Device:SDK Drivers:sai_edma 2.5.0, Device:SDK Drivers:sdhc 2.8.1, Device:SDK Drivers:wm8960 2.2.0, Device:SDK Drivers:wm8960_adapter 2.2.0, Device:SDK Drivers:xip_device 2.0.2, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
