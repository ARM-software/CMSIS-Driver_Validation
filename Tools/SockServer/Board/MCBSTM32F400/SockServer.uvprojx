# Keil uVision project SockServer.uvprojx, settings and files
target STM32F407 Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SockServer
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: HSE_VALUE=25000000
  c include: ..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
  group SockServer Source
    ../../Source/: SockServer.c Telnet_Server_UIF.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Network:CORE 7.11.1, Network:Interface:ETH 7.11.1, Network:Service:Telnet Server 7.11.1, Network:Socket:BSD 7.11.1, Network:Socket:TCP 7.11.1, Network:Socket:UDP 7.11.1, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:ST802RT1 6.2.0, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:SRAM 1.7.6, Device:Startup 2.6.3
