# Keil uVision project CMSIS_DV.uvprojx, settings and files
target Create Report (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMSIS_DV
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: PRINT_XML_REPORT=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./: main.c
  group Documentation
    ./: Abstract.txt
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.13.0
  cpu: as above
  output: CMSIS_DV
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS Driver Validation:Ethernet 1.0.0, CMSIS Driver Validation:Framework 1.4.0, CMSIS Driver Validation:I2C 1.0.0, CMSIS Driver Validation:SPI 1.0.0, CMSIS Driver Validation:USART 1.0.0, CMSIS Driver Validation:USB Device 1.0.0, CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.5.1, CMSIS Driver:Ethernet MAC 2.10, CMSIS Driver:Ethernet PHY:KSZ8081 1.01, CMSIS Driver:I2C 2.07, CMSIS Driver:SPI 2.09, CMSIS Driver:USART 2.11, CMSIS Driver:USB Device:USB 2.06, Device:RTE_Device 1.1.0, Device:Startup 2.2.4, Device:XMClib:GPIO 2.1.18, Device:XMClib:I2C 2.1.18, Device:XMClib:SCU 2.1.18, Device:XMClib:SPI 2.1.18, Device:XMClib:UART 2.1.18, Compiler:I/O:STDOUT 1.2.0
