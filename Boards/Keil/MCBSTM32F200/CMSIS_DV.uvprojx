# Keil uVision project CMSIS_DV.uvprojx, settings and files
target Create Report (6160000::V6.16::ARMCLANG)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS_DV
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000, PRINT_XML_REPORT=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: main.c
  group Documentation
    ./: Abstract.txt
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: CMSIS_DV
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS Driver Validation:Ethernet 1.0.0, CMSIS Driver Validation:Framework 1.0.0, CMSIS Driver Validation:I2C 1.0.0, CMSIS Driver Validation:MCI 1.0.0, CMSIS Driver Validation:SPI 2.0.1, CMSIS Driver Validation:USART 1.0.0, CMSIS Driver Validation:USB Device 1.0.0, CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:ST802RT1 6.2.0, CMSIS Driver:I2C 2.9, CMSIS Driver:MCI 2.6, CMSIS Driver:SPI 2.10, CMSIS Driver:USART 2.11, CMSIS Driver:USB Device:Full-speed 2.19, Device:STM32Cube Framework:Classic 1.2.1, Device:STM32Cube HAL:ADC 1.2.1, Device:STM32Cube HAL:Common 1.2.1, Device:STM32Cube HAL:Cortex 1.2.1, Device:STM32Cube HAL:DMA 1.2.1, Device:STM32Cube HAL:GPIO 1.2.1, Device:STM32Cube HAL:I2C 1.2.1, Device:STM32Cube HAL:RCC 1.2.1, Device:STM32Cube HAL:SPI 1.2.1, Device:STM32Cube HAL:USART 1.2.1, Device:Startup 2.2.1
