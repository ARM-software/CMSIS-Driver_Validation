# Keil uVision project CMSIS_DV_API.uvprojx, settings and files
target Debug (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: CMSIS_DV_API
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: main.c
  group Documentation
    ./: Abstract.txt
target Create Report (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: CMSIS_DV_API
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: PRINT_XML_REPORT=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS Driver Validation:Ethernet 1.0.0, CMSIS Driver Validation:Framework 1.0.0, CMSIS Driver Validation:I2C 1.0.0, CMSIS Driver Validation:MCI 1.0.0, CMSIS Driver Validation:SPI 1.0.0, CMSIS Driver Validation:USART 1.0.0, CMSIS Driver Validation:USB Device 1.0.0, CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:Ethernet MAC 1.6.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.2.0, CMSIS Driver:I2C 1.7.0, CMSIS Driver:MCI 1.6.0, CMSIS Driver:SPI 1.5.0, CMSIS Driver:USART 1.10.0, CMSIS Driver:USB Device:High-speed 1.13.0, Device:STM32Cube Framework:Classic 1.2.6, Device:STM32Cube HAL:Common 1.2.6, Device:STM32Cube HAL:Cortex 1.2.6, Device:STM32Cube HAL:DMA 1.2.6, Device:STM32Cube HAL:GPIO 1.2.6, Device:STM32Cube HAL:PWR 1.2.6, Device:STM32Cube HAL:RCC 1.2.6, Device:Startup 1.2.2
