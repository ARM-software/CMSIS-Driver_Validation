# Keil uVision project CMSIS_DV_API.uvprojx, settings and files
target Create XML (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.2.4.1
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Example
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: PRINT_XML_REPORT=1
  c include: .\Framework;.\TestCases
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  group Documents
    ./: Abstract.txt
  group Source
    ./: main.c
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.2.4.1
  cpu: as above
  output: Example
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Framework;.\TestCases
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x5f000
software components: CMSIS Driver Validation:CAN 1.0.0, CMSIS Driver Validation:Ethernet 1.0.0, CMSIS Driver Validation:Framework 1.0.0, CMSIS Driver Validation:I2C 1.0.0, CMSIS Driver Validation:MCI 1.0.0, CMSIS Driver Validation:SPI 1.0.0, CMSIS Driver Validation:USART 1.0.0, CMSIS Driver Validation:USB Device 1.0.0, CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:CAN 1.11, CMSIS Driver:Ethernet MAC 1.0, CMSIS Driver:Ethernet PHY:KSZ8061RNB 1.3.0, CMSIS Driver:I2C 1.0, CMSIS Driver:MCI 1.0, CMSIS Driver:SPI 1.0, CMSIS Driver:USART 1.0, CMSIS Driver:USB Device 1.5.0, Device:SAM-ESV7 Chip Library:GMAC 1.0.0, Device:SAM-ESV7 Chip Library:HSMCI 1.0.0, Device:SAM-ESV7 Chip Library:MPU 1.0.0, Device:SAM-ESV7 Chip Library:PIO 1.0.0, Device:SAM-ESV7 Chip Library:PMC 1.0.0, Device:SAM-ESV7 Chip Library:XDMAC 1.0.0, Device:SAM-ESV7 Framework:Classic 1.0.0, Device:Startup 2.2.0
