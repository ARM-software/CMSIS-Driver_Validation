# Keil uVision project CMSIS_DV.uvprojx, settings and files
target Create Report (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: CMSIS_DV
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PRINT_XML_REPORT=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\RTE\Device\LPC55S69JBD100_cm33_core0\LPC55S69_cm33_core0_flash.scf
  group Documents
    ./: Abstract.txt
  group Sources
    ./: main.c fsl_spi_cmsis.c
target Debug (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.0.0
  cpu: as above
  output: CMSIS_DV
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SDK_DEBUGCONSOLE=0, WIFI_ISM43362_DEBUG_EVR=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: as above
software components: CMSIS Driver Validation:Framework 1.4.0, CMSIS Driver Validation:WiFi 1.4.0, CMSIS Driver:SPI:Custom 2.2.0, CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:WiFi:ISM43362 1.3.0, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.1.0, Device:SDK Drivers:dma 2.3.0, Device:SDK Drivers:flexcomm 2.0.1, Device:SDK Drivers:gint 2.0.1, Device:SDK Drivers:gpio 2.1.4, Device:SDK Drivers:i2c 2.0.6, Device:SDK Drivers:inputmux 2.0.0, Device:SDK Drivers:inputmux_connections 2.0.1, Device:SDK Drivers:iocon 2.1.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:pint 2.1.3, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, Device:SDK Drivers:spi 2.0.4, Device:SDK Drivers:spi_dma 2.0.4, Device:SDK Drivers:usart 2.1.0, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.0.0
