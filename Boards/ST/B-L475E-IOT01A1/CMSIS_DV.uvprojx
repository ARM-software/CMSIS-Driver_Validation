# Keil uVision project CMSIS_DV.uvprojx, settings and files
target Create Report (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMSIS_DV
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PRINT_XML_REPORT=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x15800
  memory RVCT10: RAM 0x20015800 size 0x2800
  group Documents
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: as above
  output: CMSIS_DV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: WIFI_ISM43362_DEBUG_EVR=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x15800
  memory RVCT10: RAM 0x20015800 size 0x2800
software components: CMSIS Driver Validation:Framework 1.4.0, CMSIS Driver Validation:WiFi 1.4.0, CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:SPI 1.2.0, CMSIS Driver:WiFi:ISM43362 1.3.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:SPI 1.9.0, Device:Startup 1.3.1
